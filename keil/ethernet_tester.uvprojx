# Keil uVision project ethernet_tester.uvprojx, settings and files
target ethernet_tester (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ethernet_tester +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ../;../../../../../../source/third_party/CMSIS/Core/Include;../../../../../../source;..\Application;..\BSP;..\SysConfig;D:\ti\mspm0_sdk_2_10_00_04\source;D:\ti\mspm0_sdk_2_10_00_04\source\ti\devices;D:\ti\mspm0_sdk_2_10_00_04\source\ti\devices\msp;D:\ti\mspm0_sdk_2_10_00_04\source\ti\driverlib;D:\ti\mspm0_sdk_2_10_00_04\source\ti\driverlib\m0p;D:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3519.sct
  link misc: D:\ti\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0gx51x\driverlib.a
  group Source
    ./: startup_mspm0g351x_uvision.s
  group Application
    ../Application/: main.c app_menu.c app_menu.h
  group BSP
    ../BSP/: bsp_input.c bsp_input.h bsp_led.c bsp_led.h
  group Sysconfig
    ../Sysconfig/: ti_msp_dl_config.c ti_msp_dl_config.h
